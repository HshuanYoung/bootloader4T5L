# Keil uVision project T5L51.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\boot.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\source;..\user;..\modules;..\project;..\include\T5L
  asm include: as above
  group include
    ./: STARTUP_M5.A51
    ../include/: sys.c sys.h
    ../include/T5L/: t5los8051.h T5LOSConfig.h
  group source
    ../source/: uart.c uart.h debug_uart.c debug_uart.h timer.c timer.h
  group user
    ../user/: main.c
  group modules
    ../modules/: boot.c boot.h ota.c ota.h
